# Keil uVision project sx12xxDrivers-Eiger-f4xx.uvproj, settings and files
target sx12xxDrivers-Eiger-f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sx12xxDrivers +hex
  c flags: Optim=2
  c define: GCC_ARMCM4F STM32F4XX USE_USB_OTG_HS USE_ULPI_PHY PLATFORM=SX12xxEiger
  c include: .\src;.\src\platform;.\src\platform\sx12xxEiger;.\src\radio;.\src\platform\stm32libs\CMSIS\CM4F;.\src\platform\stm32libs\stm32f4xx\inc;.\src\platform\sx12xxEiger\Usb\stm32f4xx\inc;.\src\platform\stm32libs\STM32_USB_Device_Library\Class\cdc\inc;.\src\platform\stm32libs\STM32_USB_Device_Library\Core\inc;.\src\platform\stm32libs\STM32_USB_OTG_Driver\inc;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/: main.c
  group radio
    ./src/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group stm32libs-f4xx
    ./src/platform/stm32libs/stm32f4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c startup_stm32f4xx_keil.s
    ./src/platform/stm32libs/CMSIS/CM4F/: system_stm32f4xx.c
  group sx12xxEiger
    ./src/platform/sx12xxEiger/: fifo.c i2c.c ioe.c led.c spi.c stm32fxxx_it.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c sx1509.c uart.c
  group Usb
    ./src/platform/sx12xxEiger/Usb/stm32f4xx/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ./src/platform/stm32libs/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ./src/platform/stm32libs/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./src/platform/stm32libs/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
