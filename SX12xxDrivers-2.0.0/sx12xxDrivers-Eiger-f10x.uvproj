# Keil uVision project sx12xxDrivers-Eiger-f10x.uvproj, settings and files
target sx12xxDrivers-Eiger-f10x (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sx12xxDrivers +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: GCC_ARMCM3 USE_STDPERIPH_DRIVER STM32F10X_XL PLATFORM=SX12xxEiger
  c include: .\src;.\src\platform;.\src\platform\sx12xxEiger;.\src\radio;.\src\platform\stm32libs\CMSIS\CM3;.\src\platform\stm32libs\stm32f10x\inc;.\src\platform\sx12xxEiger\Usb\stm32f10x\inc;.\src\platform\stm32libs\STM32_USB-FS-Device_Driver\inc;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group main
    ./src/: main.c
  group radio
    ./src/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group stm32libs-f10x
    ./src/platform/stm32libs/stm32f10x/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c startup_stm32f10x_xl_keil.s
    ./src/platform/stm32libs/CMSIS/CM3/: system_stm32f10x.c
  group sx12xxEiger
    ./src/platform/sx12xxEiger/: fifo.c i2c.c ioe.c led.c spi.c stm32fxxx_it.c sx12xxEiger.c sx1232-Hal.c sx1272-Hal.c sx1276-Hal.c sx1509.c uart.c
  group Usb
    ./src/platform/stm32libs/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ./src/platform/sx12xxEiger/Usb/stm32f10x/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_bsp.c
