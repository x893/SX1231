# Keil uVision project sx12xxDrivers-Bleeper.uvproj, settings and files
target sx12xxDrivers-Bleeper (ARM-ADS)
  device: STM32L151RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sx12xxDrivers +hex
  c flags: Optim=2
  c define: GCC_ARMCM3 STM32L1XX_HD USE_STDPERIPH_DRIVER PLATFORM=Bleeper
  c include: .\src;.\src\platform;.\src\platform\Bleeper;.\src\radio;.\src\platform\stm32libs\CMSIS\CM3;.\src\platform\stm32libs\stm32l1xx\inc;.\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ./src/: main.c
  group radio
    ./src/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group stm32libs-l1xx
    ./src/platform/stm32libs/stm32l1xx/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c startup_stm32l1xx_hd_keil.s
    ./src/platform/stm32libs/CMSIS/CM3/: system_stm32l1xx.c
  group Bleeper
    ./src/platform/bleeper/: bleeper.c fifo.c i2c.c led.c spi.c stm32l1xx_it.c sx1272-Hal.c
