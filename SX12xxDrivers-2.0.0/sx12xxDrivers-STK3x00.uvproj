# Keil uVision project sx12xxDrivers-STK3x00.uvproj, settings and files
target sx12xxDrivers-STK3200 (ARM-ADS)
  device: EFM32ZG222F32 Energy Micro
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(24000000) ELITTLE
  output: sx12xxDrivers-STK3200
  c flags: Optim=2 OneElfS=1
  c define: PLATFORM=STK3200
  c include: .\src;.\src\radio;.\src\platform;.\src\platform\efm32-stk;.\src\platform\efm32libs\emlib\inc;.\src\platform\efm32libs\kits\common\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group main
    ./src/: main.c
  group radio
    ./src/radio/: radio.c sx1232.c sx1232-Misc.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group efm32libs
    ./src/platform/efm32libs/emlib/src/: em_cmu.c em_emu.c em_gpio.c em_rmu.c em_system.c em_usart.c em_leuart.c
  group efm32libs/kits
    ./src/platform/efm32-stk/: spi.c efm32-stk.c efm32xxxx_it.c sx1276-Hal.c system_efm32.c
    ./src/platform/efm32libs/kits/common/bsp/: bsp_stk_leds.c
  group efm32libs/kits/STK3200
    ./src/platform/efm32libs/cmsis/ARM/: startup_efm32zg.s
  group efm32libs/kits/STK3700
    ./src/platform/efm32libs/cmsis/ARM/: startup_efm32gg.s
target sx12xxDrivers-STK3700 (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: sx12xxDrivers-STK3200
  c flags: Optim=2 OneElfS=1
  c define: PLATFORM=STK3700
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
