# Keil uVision project wsn_sx1231.uvproj, settings and files
target wan-sx1231-stm32f429 (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: wsn_sx1231
  c flags: Optim=1 OneElfS=1
  c define: READBACK_VERIFY SX1231 DISABLE_LCD STM32F429_439xx AMATEUR_70CM NO_ISM_900
  c include: ..\..\..\transceivers;..\..\..\wsn_fhss;..\..\stm32;..\CMSIS;..\F4XX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group wsn
    ../../../wsn_fhss/: wsn.c FHSSapi.c
  group transceivers
    ../../../transceivers/sx1231/: sx1231.c
  group cpu
    ../: timers.c cpu.c spi.c uart.c
  group stm32f4xx
    ../CMSIS/: system_stm32f4xx.c
    ../CMSIS/arm/: startup_stm32f429_439xx.s
